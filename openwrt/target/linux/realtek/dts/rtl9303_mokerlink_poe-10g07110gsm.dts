// SPDX-License-Identifier: GPL-2.0-or-later
/*
 * MokerLink POE-10G07110GSM
 * 7x 10GBASE-T (PoE++) + 1x 10G SFP+, Realtek RTL9303
 *
 * STAGE 1 DEVICE TREE: the copper ports, fan control and PoE (with the
 * RTL8239 firmware installed) are verified; the PoE LEDs are not yet.
 *
 * Confirmed from the board and the stock boot log:
 *   - SoC RTL9303, 128 MiB RAM, 16 MiB Winbond W25Q128 SPI NOR
 *   - stock flash layout as declared below
 *   - console on header J4 at 115200 8N1
 *   - stock firmware is a uImage with magic 0x83800000, booted by "boota"
 *   - PHY bus/address map and lane polarity, read from the vendor U-Boot
 *   - vendor hardware profile RTL9303_8264B_3X8261BE_XGE_POE: one RTL8264B
 *     quad PHY plus three discrete RTL8261BE PHYs
 *   - PoE: two RTL8239-VB
 *   - an RTL8231 GPIO/LED expander (not used here yet)
 *   - stock U-Boot 2011.12 (1.0.0.2), firmware "KT-NOS" 1.1.1.34
 *
 * Confirmed from the stock firmware (board table "9303M7XC1XF" in
 * board_conf.ko, fan code in ski.ko):
 *   - bit-banged I2C on GPIOs with one SCL line (GPIO 8): ADT7476 fan
 *     controller at 0x2e on SDA GPIO 9, two RTL8239 PoE controllers on SDA
 *     GPIO 10 (0x20/0x21 and 0x22/0x23, broadcast 0x60), SFP+ EEPROM on SDA
 *     GPIO 11
 *   - PoE: no PSE microcontroller; the RTL8239s are driven directly over
 *     that I2C bus
 *
 * Confirmed by booting this device tree from RAM: all seven PHYs probe,
 * front ports 1-7 are lan1-lan7 and every copper port passes traffic; the
 * ADT7476 runs the fans at the stock 50 %; with the firmware loaded the
 * RTL8239s detect, classify and power an 802.3bt PD on ports 1 and 5 and
 * ethtool switches it off and on; the RTL9303 I2C master 1 reaches the
 * ADT7476 with SDA0 and the RTL8239s with SDA1, so SCL GPIO 8 is its SCL.
 *
 * Everything marked UNVERIFIED still needs confirming on hardware.
 *
 * Deliberately left out until confirmed, because a wrong guess there can
 * hurt stability rather than just disable a feature:
 *   - reset button: a floating or wrong GPIO makes /etc/rc.button/reset
 *     reboot or factory-reset the switch at random
 *   - GPIO LEDs: driving the wrong GPIO as an output can hold a PHY or the
 *     PoE controller in reset
 *   - port LED sets: without a "realtek,rtl9300-leds" node the switch keeps
 *     the LED setup the boot loader programmed
 *   - SFP cage I2C/GPIOs
 *   - the RTL8231 expander and anything wired to it
 */

/dts-v1/;

#include "rtl930x.dtsi"

#include <dt-bindings/gpio/gpio.h>
#include <dt-bindings/leds/common.h>
#include <dt-bindings/phy/phy.h>

/ {
	compatible = "mokerlink,poe-10g07110gsm", "realtek,rtl9303-soc";
	model = "MokerLink POE-10G07110GSM";

	/*
	 * Fixed I2C bus numbers, so that the PSE LED trigger names below
	 * ("pse-<bus>-<address>:port<n>:delivering") do not change.
	 */
	aliases {
		i2c0 = &i2c_fan;
		i2c1 = &i2c_poe;
		i2c2 = &i2c_sfp;
	};

	/*
	 * 128 MiB RAM ("DRAM: 128 MB") and the 115200 baud console of the
	 * vendor U-Boot are both the rtl930x.dtsi defaults.
	 */

	/*
	 * Three I2C buses that the stock firmware bit-bangs on SoC GPIOs, with
	 * one common SCL line (SDK interface 2, "software I2C"): the fan
	 * controller (SDA GPIO 9), the two RTL8239 PoE controllers (SDA GPIO
	 * 10) and the SFP+ cage (SDA GPIO 11). Bit-banged rather than on an
	 * RTL9303 I2C master because the PoE firmware download is one
	 * 25460-byte write, far beyond the 16 bytes per transfer of the master.
	 */
	i2c-gpio-shared {
		compatible = "i2c-gpio-shared-scl";
		scl-gpios = <&gpio0 8 (GPIO_ACTIVE_HIGH | GPIO_OPEN_DRAIN)>;
		i2c-gpio,delay-us = <5>;
		#address-cells = <1>;
		#size-cells = <0>;

		i2c_fan: i2c@0 {
			reg = <0>;
			sda-gpios = <&gpio0 9 (GPIO_ACTIVE_HIGH | GPIO_OPEN_DRAIN)>;
			#address-cells = <1>;
			#size-cells = <0>;

			/*
			 * Runs the fans at full speed from power-on until it
			 * is programmed; /etc/init.d/mokerlink-fan sets the
			 * speed. Its three temperature sensors are what the
			 * stock firmware follows. Pin 14 as GPIO, as the stock
			 * firmware sets it (register 0x7d = 0x03), so it acts
			 * neither as TACH4 nor as a THERM input.
			 */
			fan-controller@2e {
				compatible = "adi,adt7476";
				reg = <0x2e>;
				adi,pin14-function = "gpio";
			};
		};

		i2c_poe: i2c@1 {
			reg = <1>;
			sda-gpios = <&gpio0 10 (GPIO_ACTIVE_HIGH | GPIO_OPEN_DRAIN)>;
			#address-cells = <1>;
			#size-cells = <0>;

			/*
			 * Two RTL8239-VB, each answering on two addresses
			 * (channels 0-3 and 4-7). Port to channel mapping from
			 * the stock firmware (poePortConf_9303M7XC1XF_BT): every
			 * port is 4-pair on two consecutive channels; channels
			 * 6 and 7 of the second chip are not wired.
			 */
			pse_a: ethernet-pse@20 {
				compatible = "realtek,rtl8239";
				reg = <0x20>;

				channels {
					#address-cells = <1>;
					#size-cells = <0>;

					pse_a_ch0: channel@0 { reg = <0>; };
					pse_a_ch1: channel@1 { reg = <1>; };
					pse_a_ch2: channel@2 { reg = <2>; };
					pse_a_ch3: channel@3 { reg = <3>; };
					pse_a_ch4: channel@4 { reg = <4>; };
					pse_a_ch5: channel@5 { reg = <5>; };
					pse_a_ch6: channel@6 { reg = <6>; };
					pse_a_ch7: channel@7 { reg = <7>; };
				};

				pse-pis {
					#address-cells = <1>;
					#size-cells = <0>;

					/* front port 4 */
					pse_port4: pse-pi@0 {
						reg = <0>;
						#pse-cells = <0>;
						pairset-names = "alternative-a", "alternative-b";
						pairsets = <&pse_a_ch0>, <&pse_a_ch1>;
					};

					/* front port 5 */
					pse_port5: pse-pi@1 {
						reg = <1>;
						#pse-cells = <0>;
						pairset-names = "alternative-a", "alternative-b";
						pairsets = <&pse_a_ch2>, <&pse_a_ch3>;
					};

					/* front port 6 */
					pse_port6: pse-pi@2 {
						reg = <2>;
						#pse-cells = <0>;
						pairset-names = "alternative-a", "alternative-b";
						pairsets = <&pse_a_ch4>, <&pse_a_ch5>;
					};

					/* front port 7 */
					pse_port7: pse-pi@3 {
						reg = <3>;
						#pse-cells = <0>;
						pairset-names = "alternative-a", "alternative-b";
						pairsets = <&pse_a_ch6>, <&pse_a_ch7>;
					};
				};
			};

			pse_b: ethernet-pse@22 {
				compatible = "realtek,rtl8239";
				reg = <0x22>;

				channels {
					#address-cells = <1>;
					#size-cells = <0>;

					pse_b_ch0: channel@0 { reg = <0>; };
					pse_b_ch1: channel@1 { reg = <1>; };
					pse_b_ch2: channel@2 { reg = <2>; };
					pse_b_ch3: channel@3 { reg = <3>; };
					pse_b_ch4: channel@4 { reg = <4>; };
					pse_b_ch5: channel@5 { reg = <5>; };
				};

				pse-pis {
					#address-cells = <1>;
					#size-cells = <0>;

					/* front port 1 */
					pse_port1: pse-pi@0 {
						reg = <0>;
						#pse-cells = <0>;
						pairset-names = "alternative-a", "alternative-b";
						pairsets = <&pse_b_ch0>, <&pse_b_ch1>;
					};

					/* front port 2 */
					pse_port2: pse-pi@1 {
						reg = <1>;
						#pse-cells = <0>;
						pairset-names = "alternative-a", "alternative-b";
						pairsets = <&pse_b_ch2>, <&pse_b_ch3>;
					};

					/* front port 3 */
					pse_port3: pse-pi@2 {
						reg = <2>;
						#pse-cells = <0>;
						pairset-names = "alternative-a", "alternative-b";
						pairsets = <&pse_b_ch4>, <&pse_b_ch5>;
					};
				};
			};
		};

		/* SFP+ module EEPROM (0x50); no "sff,sfp" node yet */
		i2c_sfp: i2c@2 {
			reg = <2>;
			sda-gpios = <&gpio0 11 (GPIO_ACTIVE_HIGH | GPIO_OPEN_DRAIN)>;
			#address-cells = <1>;
			#size-cells = <0>;
		};
	};
};

&spi0 {
	status = "okay";

	flash@0 {
		/* Winbond W25Q128 (JEDEC ID EF4018) */
		compatible = "jedec,spi-nor";
		reg = <0>;
		spi-max-frequency = <10000000>;

		/*
		 * Same layout as the stock firmware's partition table. Everything
		 * except "firmware" is read-only so that OpenWrt never touches the
		 * boot loader, its environment, the board info or the stock
		 * configuration. That keeps a return to stock possible.
		 */
		partitions {
			compatible = "fixed-partitions";
			#address-cells = <1>;
			#size-cells = <1>;

			/* stock: LOADER */
			partition@0 {
				label = "u-boot";
				reg = <0x0000000 0x00e0000>;
				read-only;
			};

			/* stock: BDINFO */
			partition@e0000 {
				label = "u-boot-env";
				reg = <0x00e0000 0x0010000>;
				read-only;
			};

			/* stock: SYSINFO */
			partition@f0000 {
				label = "u-boot-env2";
				reg = <0x00f0000 0x0010000>;
				read-only;
			};

			/* stock: JFFS2 CFG */
			partition@100000 {
				label = "jffs";
				reg = <0x0100000 0x0100000>;
				read-only;
			};

			/* stock: JFFS2 LOG */
			partition@200000 {
				label = "jffs2";
				reg = <0x0200000 0x0100000>;
				read-only;
			};

			/* stock: RUNTIME */
			partition@300000 {
				compatible = "openwrt,uimage", "denx,uimage";
				/*
				 * The stock RUNTIME image is a uImage with this magic.
				 * Must match UIMAGE_MAGIC in image/rtl930x.mk.
				 */
				openwrt,ih-magic = <0x83800000>;
				label = "firmware";
				reg = <0x0300000 0x0c00000>;
			};

			/* stock: OEMINFO */
			partition@f00000 {
				label = "oeminfo";
				reg = <0x0f00000 0x0100000>;
				read-only;
			};
		};
	};
};

/*
 * PHYs, as the vendor U-Boot maps them (SMI_PORT_POLLING_SEL and
 * SMI_PORT*_ADDR_CTRL read after `rtk network on`):
 *   MAC  0: RTL8261BE, SMI bus 1, address 0 (PHY ID read back: 001c:caf3)
 *   MAC  8: single PHY, SMI bus 2, address 0
 *   MAC 16: single PHY, SMI bus 3, address 0
 *   MAC 20, 24, 25, 26: RTL8264B quad, SMI bus 0, addresses 0-3
 * The three single PHYs are the RTL8261BEs of the vendor hardware profile.
 */
&mdio_bus0 {
	ethernet-phy-package@0 {
		#address-cells = <1>;
		#size-cells = <0>;
		reg = <0>;

		PHY_C45(20, 0)
		PHY_C45(24, 1)
		PHY_C45(25, 2)
		PHY_C45(26, 3)
	};
};

&mdio_bus1 {
	PHY_C45(0, 0)
};

&mdio_bus2 {
	PHY_C45(8, 0)
};

&mdio_bus3 {
	PHY_C45(16, 0)
};

/*
 * Lane polarity on both ends of every PHY link, exactly as the vendor U-Boot
 * programs it after `rtk network on` (read back from the RTL8264B VEND1
 * register 0xc1 and the SerDes polarity registers). The RTL8261BE links
 * (MAC 0/8/16, SerDes 2-4) and the SFP+ lane (SerDes 9) are normal on both
 * ends. The RTL826x PHY driver (&phyN) and the SerDes driver (&serdesN) both
 * default to "normal" and reprogram polarity on every init, so these lines
 * are required: without them the RTL8264B ports link up but pass no frames.
 */
&phy20 { tx-polarity = <PHY_POL_INVERT>; };
&phy24 { rx-polarity = <PHY_POL_INVERT>; };
&phy25 { tx-polarity = <PHY_POL_INVERT>; };
&phy26 { rx-polarity = <PHY_POL_INVERT>; };

&serdes5 { rx-polarity = <PHY_POL_INVERT>; };
&serdes6 { tx-polarity = <PHY_POL_INVERT>; };
&serdes7 { rx-polarity = <PHY_POL_INVERT>; };
&serdes8 { tx-polarity = <PHY_POL_INVERT>; };

&switch0 {
	ethernet-ports {
		#address-cells = <1>;
		#size-cells = <0>;

		/*
		 * RJ45 10GBASE-T ports: front ports 1-7 are MAC ports 0, 8, 16,
		 * 20, 24, 25, 26 (port test in the RAM-booted image), so front
		 * ports 1-3 are the RTL8261BEs and 4-7 the RTL8264B.
		 */
		SWITCH_PORT_SDS(0, 1, 2, 0, usxgmii)
		SWITCH_PORT_SDS(8, 2, 3, 0, usxgmii)
		SWITCH_PORT_SDS(16, 3, 4, 0, usxgmii)
		SWITCH_PORT_SDS(20, 4, 5, 0, usxgmii)
		SWITCH_PORT_SDS(24, 5, 6, 0, usxgmii)
		SWITCH_PORT_SDS(25, 6, 7, 0, usxgmii)
		SWITCH_PORT_SDS(26, 7, 8, 0, usxgmii)

		/*
		 * SFP+ cage, lan8. UNVERIFIED: MAC port 27 on SerDes 9.
		 *
		 * Stage 1 runs the cage as a bare 10GBASE-R link with in-band
		 * status instead of a "sff,sfp" node, so no unconfirmed I2C bus
		 * or GPIO is touched. 10G optics, DAC cables and 10GBASE-T SFP+
		 * modules link up this way; 1G modules and module EEPROM/DOM
		 * readout need the full SFP description (docs/05-porting.md).
		 */
		port27: port@27 {
			reg = <27>;
			label = "lan8";
			pcs-handle = <&serdes9 0>;
			phy-mode = "10gbase-r";
			managed = "in-band-status";
		};

		/* CPU port */
		port@28 {
			ethernet = <&ethernet0>;
			reg = <28>;
			phy-mode = "internal";

			fixed-link {
				speed = <1000>;
				full-duplex;
			};
		};
	};

	/*
	 * PoE status LEDs. The stock firmware (poe_led_detect_monitor in
	 * ski.ko) takes LED 2 of every RJ45 port, the third in the serial LED
	 * stream, under software control and switches it on while the port
	 * delivers power. The PoE LEDs are green.
	 */
	led-controller@cc48 {
		compatible = "realtek,rtl9301-port-leds";
		reg = <0xcc48 0x84>;
		#address-cells = <2>;
		#size-cells = <0>;

		led@0,2 {
			reg = <0 2>;
			color = <LED_COLOR_ID_GREEN>;
			function = "poe";
			function-enumerator = <1>;
			linux,default-trigger = "pse-1-0022:port0:delivering";
		};

		led@8,2 {
			reg = <8 2>;
			color = <LED_COLOR_ID_GREEN>;
			function = "poe";
			function-enumerator = <2>;
			linux,default-trigger = "pse-1-0022:port1:delivering";
		};

		led@10,2 {
			reg = <16 2>;
			color = <LED_COLOR_ID_GREEN>;
			function = "poe";
			function-enumerator = <3>;
			linux,default-trigger = "pse-1-0022:port2:delivering";
		};

		led@14,2 {
			reg = <20 2>;
			color = <LED_COLOR_ID_GREEN>;
			function = "poe";
			function-enumerator = <4>;
			linux,default-trigger = "pse-1-0020:port0:delivering";
		};

		led@18,2 {
			reg = <24 2>;
			color = <LED_COLOR_ID_GREEN>;
			function = "poe";
			function-enumerator = <5>;
			linux,default-trigger = "pse-1-0020:port1:delivering";
		};

		led@19,2 {
			reg = <25 2>;
			color = <LED_COLOR_ID_GREEN>;
			function = "poe";
			function-enumerator = <6>;
			linux,default-trigger = "pse-1-0020:port2:delivering";
		};

		led@1a,2 {
			reg = <26 2>;
			color = <LED_COLOR_ID_GREEN>;
			function = "poe";
			function-enumerator = <7>;
			linux,default-trigger = "pse-1-0020:port3:delivering";
		};
	};
};

/* PoE: front ports 1-7 to their PSE PIs */
&phy0 { pses = <&pse_port1>; };
&phy8 { pses = <&pse_port2>; };
&phy16 { pses = <&pse_port3>; };
&phy20 { pses = <&pse_port4>; };
&phy24 { pses = <&pse_port5>; };
&phy25 { pses = <&pse_port6>; };
&phy26 { pses = <&pse_port7>; };
